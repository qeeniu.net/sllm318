[IBIS Ver]   5.0
[File Name]  RX.ibs
[File Rev]   1.0
[Component]  ibis_50ohm
[Manufacturer] Agilent Technologies, Inc.
[Package]
R_pkg  0.0   NA   NA
L_pkg  0.0   NA   NA
C_pkg  0.0   NA   NA
[Pin]   signal_name   model_name   R_pin L_pin  C_pin
2p   IBIS_50ohm_Rx_2p   ibis_50ohm_rx
2n   IBIS_50ohm_Rx_2n   ibis_50ohm_rx
[Diff_Pin] inv_pin vdiff tdelay_typ tdelay_min tdelay_max
2p   2n   NA   NA   NA   NA
[Model] ibis_50ohm_rx
Model_type Terminator
C_comp 0p 0p 0p
[Rpower] 1.0e9  1.0e9  1.0e9
[Rgnd] 50.0  50.0  50.0
[Temperature_Range] 25 125 0
[Voltage Range] 1.0 1.0 1.0
[Algorithmic Model]
Executable Windows_VisualC++ExpressEdition9.0.30729_32 IdealRx.dll IdealRx.ami
[End Algorithmic Model]
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| Models and submodels in the file (1): ibis_50ohm_rx (Terminator)
